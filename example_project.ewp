# IAR project example_project.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x40
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    src/: ezLCD_103_buttons.c ezLCD_103_buttons.h ezLCD_103_colors.c ezLCD_103_colors.h ezLCD_103_common.c ezLCD_103_common.h ezLCD_103_coordinates.c ezLCD_103_coordinates.h ezLCD_103_curves.c ezLCD_103_curves.h ezLCD_103_driver.h ezLCD_103_fill.c ezLCD_103_fill.h ezLCD_103_frames.c ezLCD_103_frames.h ezLCD_103_images.c ezLCD_103_images.h ezLCD_103_lines.c ezLCD_103_lines.h ezLCD_103_pen.c ezLCD_103_pen.h ezLCD_103_pixels.c ezLCD_103_pixels.h ezLCD_103_polygons.c ezLCD_103_polygons.h ezLCD_103_system.c ezLCD_103_system.h ezLCD_103_text.c ezLCD_103_text.h ezLCD_103_user_config.h main.c
